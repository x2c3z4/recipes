## kernel_drivers/chdev/hello/Kconfig
```kconfig
config HELLO
	tristate "hello char device driver"
	default y
	help
        my hello happy
```
